# Keil uVision project emote-bootloader.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: emote-bootloader +hex
  AfterMake: fromelf --bin --output ./debug/emote-bootloader.bin ./debug/emote-bootloader.axf
  c flags: Optim=1
  c define: STM32F10X_XL USE_STDPERIPH_DRIVER USE_FULL_ASSERT
  c include: ..\USART;.\cmsis;.\emlib;.\source
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group cmsis
    ./cmsis/: core_cm3.c core_cm3.h core_cmFunc.h core_cmInstr.h stm32f10x.h system_stm32f10x.h system_stm32f10x.c
  group emlib
    ./emlib/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_usart.h
  group source
    ./source/: Retarget.c Serial.c stm32f10x_it.c usart1_conf.c startup_stm32f10x_xl.s common.c download.c main.c common.h ymodem.h upload.c ymodem.c
