# Keil uVision project app_hello.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app_hello_moteid
  AfterMake: fromelf --bin --output ./obj/app_hello_moteid.bin ./obj/app_hello_moteid.axf
  c flags: Optim=1
  c define: STM32F10X_XL USE_STDPERIPH_DRIVER
  c include: .\cmsis;.\emlib;..\APP_HELLO
  memory RVCT4: ROM 0x8006000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: startup_stm32f10x_xl.s Hello.c Retarget.c system_stm32f10x.c stm32f10x_conf.h stm32f10x_it.h stm32f10x_it.c Serial.c usart1_conf.c common.h common.c
  group emlib
    ./emlib/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c eeprom.c eeprom.h stm32f10x_flash.h stm32f10x_usart.h stm32f10x.h
software components: CMSIS:CORE 4.3.0
