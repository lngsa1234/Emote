# Keil uVision project tinyos-stm32.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: tinyos-stm32 +hex
  AfterMake: fromelf --bin --output .\obj\tinyos-stm32.bin .\obj\tinyos-stm32.axf
  c flags: Optim=1
  c define: STM32F10X_XL
  c include: F:\share\TinyOS-STM-v0.9b\tos\chips\stm32\fwlib\src;F:\share\TinyOS-STM-v0.9b\tos\chips\stm32\fwlib\inc;F:\share\TinyOS-STM-v0.9b\tos\chips\stm32\uart-serial;F:\share\TinyOS-STM-v0.9b\tos\chips\stm32\fwlib
  memory RVCT4: ROM 0x8006000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: startup_stm32f10x_xl.s
    F:/share/TinyOS-STM-v0.9b/apps/UsartSerialTest/build/emote/: appmangle.c
    F:/share/TinyOS-STM-v0.9b/tos/chips/stm32/fwlib/: system_stm32f10x.h stm32f10x.h core_cm3.h
  group fwlibsrc
    F:/share/TinyOS-STM-v0.9b/tos/chips/stm32/fwlib/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group fwlibinc
    F:/share/TinyOS-STM-v0.9b/tos/chips/stm32/fwlib/inc/: misc.h rt_misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group usartserial
    F:/share/TinyOS-STM-v0.9b/tos/chips/stm32/uart-serial/: Serial.c usart_conf.c Serial.h usart_conf.h
