# Keil uVision project emoteboot.uvprojx, settings and files
target bootloader (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: emoteboot
  AfterMake: fromelf --bin --output=./Objects/emoteboot.bin ./Objects/emoteboot.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ./cmsis;./emlib;./src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group cmsis
    ./cmsis/: core_cm3.c system_stm32f10x.c core_cm3.h core_cmFunc.h core_cmInstr.h stm32f10x.h system_stm32f10x.h
  group emlib
    ./emlib/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_usart.h
  group src
    ./src/: common.c common.h download.c main.c retarget.c serial.c serial.h startup_stm32f10x_xl.s stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h uart.h upload.c usart1_conf.c ymodem.c ymodem.h
software components: CMSIS:CORE 4.3.0
